## conf/local.conf
```bitbake
include "application.conf"

mongodb.uri="mongodb://guest-xp:guest-xp-2014@ds033669.mongolab.com:33669/guest-xp"
```
